# Keil uVision project Snake.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Snake +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\Board;.\Core;.\Fw_lib\inc;.\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Fw_lib
    ../lab/Fw_lib/src/: stm32f10x_rcc.c stm32f10x_gpio.c
  group Core
    ../lab/Core/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group Board
    ../lab/Board/: CFONT.H FONT.H IERG3810_Buzzer.c IERG3810_Buzzer.h IERG3810_io.c IERG3810_io.h IERG3810_KEY.c IERG3810_KEY.h IERG3810_LED.c IERG3810_LED.h IERG3810_TFTLCD.c IERG3810_TFTLCD.h IERG3810_USART.c IERG3810_USART.h
    ./Board/: IERG3810_Clock.c IERG3810_Clock.h Board.c Board.h JoyPad.c JoyPad.h
  group User
    ./User/: stm32f10x_it.c test.c
